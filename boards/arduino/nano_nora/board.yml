## boards/arduino/nano_nora/board.yml
```yaml
board:
  name: arduino_nano_nora
  full_name: arduino_nano_nora
  vendor: arduino
  socs:
  - name: esp32s3
```
